# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\System;.\User
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Font.h DS18B20.c DS18B20.h
  group System
    ./System/: Delay.c Delay.h Sys.h
